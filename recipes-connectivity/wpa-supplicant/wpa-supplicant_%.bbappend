#Add Debug / P2P Flag

EXTRA_OEMAKE =' \
	CONFIG_DEBUG_FILE=y \
	CONFIG_P2P=Y \
	'
